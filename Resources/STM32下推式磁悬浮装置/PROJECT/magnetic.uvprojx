# Keil uVision project magnetic.uvprojx, settings and files
target Magnetic (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IROM(0x08000000,0x00010000) IRAM(0x20000000,0x00005000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\CORE;..\STM32F10x_FWLib\src;..\STM32F10x_FWLib\inc;..\HARDWARE\ADC;..\HARDWARE\BLUETOOTH;..\HARDWARE\CONTROL;..\HARDWARE\DRIVE;..\HARDWARE\EXTI;..\HARDWARE\LED;..\HARDWARE\OLED;..\HARDWARE\PID;..\HARDWARE\TIM;..\..\Template
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../USER/: main.c stm32f10x_it.c system_stm32f10x.c
  group HARDWARE
    ../HARDWARE/ADC/: bsp_adc.c
    ../HARDWARE/BLUETOOTH/: bsp_bluetooth.c
    ../HARDWARE/OLED/: bsp_oled_iic.c
    ../HARDWARE/DRIVE/: bsp_drive.c
    ../HARDWARE/LED/: bsp_led.c
    ../HARDWARE/TIM/: bsp_tim.c
  group PID
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/CONTROL/: control.c
  group SYSTEM
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
  group CORE
    ../CORE/: core_cm3.c startup_stm32f10x_md.s
  group FWLIB
    ../STM32F10x_FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group README
    ../: readme.txt
