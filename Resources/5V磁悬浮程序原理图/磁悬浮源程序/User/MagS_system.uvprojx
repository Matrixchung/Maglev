# Keil uVision project MagS_system.uvprojx, settings and files
target MagS (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: MagS_system +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\User;..\FWLib\inc;..\Core;..\Device;..\App
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Core
    ../Core/: core_cm3.c startup_stm32f10x_hd.s
  group User
    ./: main.c stm32f10x_it.c system_stm32f10x.c
  group FWLib
    ../FWLib/src/: misc.c stm32f10x_adc.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_iwdg.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group App
    ../App/: PID.c App.c
  group Device
    ../Device/: AdcDevice.c UsartDevice.c ClkDevice.c PwmDevice.c LedDevice.c
